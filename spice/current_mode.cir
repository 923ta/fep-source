DEMO current-mode

.global vdd vss
vdd vcc 0
